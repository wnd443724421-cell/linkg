# Keil uVision project soft.uvprojx, settings and files
target soft (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L031G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(32000000) CPUTYPE("Cortex-M0+") TZ
  output: linkg_mcu_v2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ../Core/Inc;../bsp;../service;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32l031xx.s
  group Core
    ../Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c system_stm32l0xx.c
  group BSP
    ../bsp/: bsp_gpio.c bsp_uart.c
  group Service
    ../service/: sbus_bridge.c
  group HAL
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
